# Keil uVision project TEMPLATE.uvprojx, settings and files
target TEMPLATE (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TEMPLATE +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\USER;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USMART;..\HARDWARE\LCD;..\HARDWARE\KEY;..\HARDWARE\RTC;..\HARDWARE\LED;..\HARDWARE\ADC;..\HARDWARE\I2C;..\HARDWARE\OLED;..\HARDWARE\TIM;..\HARDWARE\USART3;..\HARDWARE\DMA
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: startup_stm32f10x_hd.s core_cm3.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/I2C/: i2c_oled.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/USART3/: usart3.c
    ../HARDWARE/TIM/: timer.c
    ../HARDWARE/DMA/: dma.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group FWLIB
    ../STM32F10x_FWLib/src/: FWLIB.lib
